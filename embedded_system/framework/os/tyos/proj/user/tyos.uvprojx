# Keil uVision project tyos.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: tyos
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32H743xx,ARM_MATH_CM7
  c include: ..\..\..\..\base;..\..\..\..\..\stm32\stm32h7\HAL;..\..\..\..\..\stm32\stm32h7\mathhelper;..\..\..\..\..\stm32\stm32h7\mpu;..\..\..\..\..\stm32\stm32h7\sys;..\..\..\..\os;..\..\..\..\..\stm32\stm32h7\peripheral;..\..\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  memory RVCT10: RAM 0x24010000 size 0x70000
  group user
    ./: main.c startup_stm32h743xx.s
  group hal
    ../../../../../stm32/stm32h7/HAL/: USART.c GPIO.c
  group framework
    ../../../../base/: Framework.c LinkedList.c Memory.c
    ../../src/: ArrayList.c
  group sys
    ../../../../../stm32/stm32h7/sys/: sys.c
  group mathhelper
    ../../../../../stm32/stm32h7/mathhelper/: MathHelper.c arm_cortexM7lfdp_math.lib
  group extern
    ../../../../../stm32/stm32h7/mpu/: mpu.c
  group tyos
    ../../src/: TYOS_Kernel.c TYOS_MultProcess.c TYOS_Assembly.s
